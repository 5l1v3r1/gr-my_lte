<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PDCCH</value></param>
<param><key>category</key><value>/MY_LTE</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_CCE</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>13</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_ant</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RNTI</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>aggregation1</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>aggregation2</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cell_id</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>my_lte_conv_enc</key>
<param><key>id</key><value>my_lte_conv_enc_0</value></param>
<param><key>constraint_length</key><value>7</value></param>
<param><key>g</key><value>(133,171,165)</value></param>
<param><key>rate</key><value>3</value></param>
<param><key>tail_bit</key><value>True</value></param>
</block>
<block>
<key>my_lte_conv_enc</key>
<param><key>id</key><value>my_lte_conv_enc_0_0</value></param>
<param><key>constraint_length</key><value>7</value></param>
<param><key>g</key><value>(133,171,165)</value></param>
<param><key>rate</key><value>3</value></param>
<param><key>tail_bit</key><value>True</value></param>
</block>
<block>
<key>my_lte_crc_attachment</key>
<param><key>id</key><value>my_lte_crc_attachment_0</value></param>
<param><key>CRC_type</key><value>0x00011021</value></param>
<param><key>ch_name</key><value>"DCI"</value></param>
<param><key>ninput_needed</key><value>100</value></param>
<param><key>N_ant</key><value>N_ant</value></param>
<param><key>rnti</key><value>RNTI</value></param>
</block>
<block>
<key>my_lte_crc_attachment</key>
<param><key>id</key><value>my_lte_crc_attachment_0_0</value></param>
<param><key>CRC_type</key><value>0x00011021</value></param>
<param><key>ch_name</key><value>"DCI"</value></param>
<param><key>ninput_needed</key><value>100</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>rnti</key><value>1+10</value></param>
</block>
<block>
<key>my_lte_layer_mapper</key>
<param><key>id</key><value>my_lte_layer_mapper_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>10000</value></param>
</block>
<block>
<key>my_lte_modulation_mapper</key>
<param><key>id</key><value>my_lte_modulation_mapper_0</value></param>
<param><key>mod_type</key><value>"BPSK"</value></param>
<param><key>set_align</key><value>10000</value></param>
</block>
<block>
<key>my_lte_pdcch_interleaver</key>
<param><key>id</key><value>my_lte_pdcch_interleaver_0</value></param>
<param><key>N_ant</key><value>N_ant</value></param>
<param><key>N_cell_id</key><value>cell_id</value></param>
</block>
<block>
<key>my_lte_pdcch_mux</key>
<param><key>id</key><value>my_lte_pdcch_mux_0</value></param>
<param><key>n_cce</key><value>N_CCE</value></param>
<param><key>n_pdcch</key><value>num_pdcch</value></param>
</block>
<block>
<key>my_lte_precoder</key>
<param><key>id</key><value>my_lte_precoder_0</value></param>
<param><key>normal_cp</key><value>True</value></param>
<param><key>is_phich</key><value>False</value></param>
<param><key>n_phich_group</key><value>1</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>10000</value></param>
</block>
<block>
<key>my_lte_rate_match_conv</key>
<param><key>id</key><value>my_lte_rate_match_conv_0</value></param>
<param><key>N_e_bits</key><value>aggregation1</value></param>
</block>
<block>
<key>my_lte_rate_match_conv</key>
<param><key>id</key><value>my_lte_rate_match_conv_0_0</value></param>
<param><key>N_e_bits</key><value>aggregation2</value></param>
</block>
<block>
<key>my_lte_scrambler</key>
<param><key>id</key><value>my_lte_scrambler_0</value></param>
<param><key>name</key><value>"DCI"</value></param>
<param><key>rnti</key><value>RNTI</value></param>
<param><key>set_align</key><value>N_CCE * 8 * 9</value></param>
<param><key>N_id_cell</key><value>cell_id</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_pdcch</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>my_lte_conv_enc_0</source_block_id><sink_block_id>my_lte_rate_match_conv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_conv_enc_0_0</source_block_id><sink_block_id>my_lte_rate_match_conv_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_crc_attachment_0</source_block_id><sink_block_id>my_lte_conv_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_crc_attachment_0_0</source_block_id><sink_block_id>my_lte_conv_enc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_layer_mapper_0</source_block_id><sink_block_id>my_lte_precoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_modulation_mapper_0</source_block_id><sink_block_id>my_lte_layer_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_pdcch_interleaver_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_pdcch_mux_0</source_block_id><sink_block_id>my_lte_scrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_precoder_0</source_block_id><sink_block_id>my_lte_pdcch_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_rate_match_conv_0</source_block_id><sink_block_id>my_lte_pdcch_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_rate_match_conv_0_0</source_block_id><sink_block_id>my_lte_pdcch_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>my_lte_scrambler_0</source_block_id><sink_block_id>my_lte_modulation_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>my_lte_crc_attachment_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>my_lte_crc_attachment_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
