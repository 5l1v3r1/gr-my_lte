<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PHICH_coding</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>/MY_LTE</value></param>
</block>
<block>
<key>my_lte_repeater</key>
<param><key>id</key><value>my_lte_repeater_0</value></param>
<param><key>n</key><value>3</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>my_lte_layer_mapper</key>
<param><key>id</key><value>my_lte_layer_mapper_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_phich_sequence</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>my_lte_precoder</key>
<param><key>id</key><value>my_lte_precoder_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>20</value></param>
<param><key>is_phich</key><value>True</value></param>
<param><key>n_phich_group</key><value>N_phich_sequence</value></param>
<param><key>normal_cp</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cell_id</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RNTI</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>my_lte_phich_alignment</key>
<param><key>id</key><value>my_lte_phich_alignment_0</value></param>
<param><key>normal_cp</key><value>True</value></param>
<param><key>n_phich_group</key><value>N_phich_sequence</value></param>
</block>
<block>
<key>my_lte_modulation_mapper</key>
<param><key>id</key><value>my_lte_modulation_mapper_0</value></param>
<param><key>mod_type</key><value>"BPSK"</value></param>
<param><key>set_align</key><value>10</value></param>
</block>
<block>
<key>my_lte_phich_orthogonalization</key>
<param><key>id</key><value>my_lte_phich_orthogonalization_0</value></param>
<param><key>normal_cp</key><value>True</value></param>
<param><key>N_PHICH_seq</key><value>1</value></param>
</block>
<block>
<key>my_lte_scrambler_phich</key>
<param><key>id</key><value>my_lte_scrambler_phich_0</value></param>
<param><key>N_id_cell</key><value>cell_id</value></param>
<param><key>rnti</key><value>RNTI</value></param>
<param><key>set_align</key><value>12</value></param>
</block>
<connection><source_block_id>my_lte_layer_mapper_0</source_block_id><sink_block_id>my_lte_precoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_phich_alignment_0</source_block_id><sink_block_id>my_lte_layer_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>my_lte_repeater_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_modulation_mapper_0</source_block_id><sink_block_id>my_lte_phich_orthogonalization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_repeater_0</source_block_id><sink_block_id>my_lte_modulation_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_precoder_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_phich_orthogonalization_0</source_block_id><sink_block_id>my_lte_scrambler_phich_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_scrambler_phich_0</source_block_id><sink_block_id>my_lte_phich_alignment_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
