<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PHICH_group_gen</value></param>
<param><key>description</key><value>1 Group of PHICH for normal cp</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>/MY_LTE</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_4</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_5</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_7</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_6</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cell_id</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>PHICH_coding</key>
<param><key>id</key><value>PHICH_coding_0_5</value></param>
<param><key>N_phich_sequence</key><value>1</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>RNTI</key><value>RNTI</value></param>
</block>
<block>
<key>PHICH_coding</key>
<param><key>id</key><value>PHICH_coding_0</value></param>
<param><key>N_phich_sequence</key><value>2</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>RNTI</key><value>RNTI</value></param>
</block>
<block>
<key>PHICH_coding</key>
<param><key>id</key><value>PHICH_coding_0_0</value></param>
<param><key>N_phich_sequence</key><value>4</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>RNTI</key><value>RNTI</value></param>
</block>
<block>
<key>PHICH_coding</key>
<param><key>id</key><value>PHICH_coding_0_2</value></param>
<param><key>N_phich_sequence</key><value>5</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>RNTI</key><value>RNTI</value></param>
</block>
<block>
<key>PHICH_coding</key>
<param><key>id</key><value>PHICH_coding_0_3</value></param>
<param><key>N_phich_sequence</key><value>6</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>RNTI</key><value>RNTI</value></param>
</block>
<block>
<key>PHICH_coding</key>
<param><key>id</key><value>PHICH_coding_0_4</value></param>
<param><key>N_phich_sequence</key><value>7</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>RNTI</key><value>RNTI</value></param>
</block>
<block>
<key>PHICH_coding</key>
<param><key>id</key><value>PHICH_coding_0_6</value></param>
<param><key>N_phich_sequence</key><value>0</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>RNTI</key><value>RNTI</value></param>
</block>
<block>
<key>PHICH_coding</key>
<param><key>id</key><value>PHICH_coding_0_1</value></param>
<param><key>N_phich_sequence</key><value>3</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>RNTI</key><value>RNTI</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RNTI</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0_6</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0_0</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0_1</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0_2</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0_3</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0_4</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0_5</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<connection><source_block_id>my_lte_lte_random_bit_gen_0_0</source_block_id><sink_block_id>PHICH_coding_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0</source_block_id><sink_block_id>PHICH_coding_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0_6</source_block_id><sink_block_id>PHICH_coding_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PHICH_coding_0_5</source_block_id><sink_block_id>pad_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PHICH_coding_0</source_block_id><sink_block_id>pad_sink_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PHICH_coding_0_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PHICH_coding_0_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PHICH_coding_0_2</source_block_id><sink_block_id>pad_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0_2</source_block_id><sink_block_id>PHICH_coding_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0_3</source_block_id><sink_block_id>PHICH_coding_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0_4</source_block_id><sink_block_id>PHICH_coding_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0_5</source_block_id><sink_block_id>PHICH_coding_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PHICH_coding_0_3</source_block_id><sink_block_id>pad_sink_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PHICH_coding_0_4</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PHICH_coding_0_6</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0_1</source_block_id><sink_block_id>PHICH_coding_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
