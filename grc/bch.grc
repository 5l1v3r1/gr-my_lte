<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pbch</value></param>
<param><key>category</key><value>/MY_LTE</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_ant</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RNTI</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cell_id</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>my_lte_conv_enc</key>
<param><key>id</key><value>my_lte_conv_enc_0</value></param>
<param><key>constraint_length</key><value>7</value></param>
<param><key>g</key><value>(0133,0171,0156)</value></param>
<param><key>rate</key><value>3</value></param>
<param><key>tail_bit</key><value>True</value></param>
</block>
<block>
<key>my_lte_crc_attachment</key>
<param><key>id</key><value>my_lte_crc_attachment_0</value></param>
<param><key>CRC_type</key><value>0x00011021</value></param>
<param><key>ch_name</key><value>"BCH"</value></param>
<param><key>ninput_needed</key><value>20</value></param>
<param><key>N_ant</key><value>N_ant</value></param>
<param><key>rnti</key><value>RNTI</value></param>
</block>
<block>
<key>my_lte_layer_mapper</key>
<param><key>id</key><value>my_lte_layer_mapper_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>2000</value></param>
</block>
<block>
<key>my_lte_modulation_mapper</key>
<param><key>id</key><value>my_lte_modulation_mapper_0</value></param>
<param><key>mod_type</key><value>"QPSK"</value></param>
<param><key>set_align</key><value>2000</value></param>
</block>
<block>
<key>my_lte_precoder</key>
<param><key>id</key><value>my_lte_precoder_0</value></param>
<param><key>normal_cp</key><value>True</value></param>
<param><key>is_phich</key><value>False</value></param>
<param><key>n_phich_group</key><value>1</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>2000</value></param>
</block>
<block>
<key>my_lte_rate_match_conv</key>
<param><key>id</key><value>my_lte_rate_match_conv_0</value></param>
<param><key>N_e_bits</key><value>1920</value></param>
</block>
<block>
<key>my_lte_scrambler</key>
<param><key>id</key><value>my_lte_scrambler_0</value></param>
<param><key>name</key><value>"PBCH"</value></param>
<param><key>rnti</key><value>1</value></param>
<param><key>set_align</key><value>1920</value></param>
<param><key>N_id_cell</key><value>cell_id</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>normal_cp</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>PBCH</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>source</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>my_lte_conv_enc_0</source_block_id><sink_block_id>my_lte_rate_match_conv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_crc_attachment_0</source_block_id><sink_block_id>my_lte_conv_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_layer_mapper_0</source_block_id><sink_block_id>my_lte_precoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_modulation_mapper_0</source_block_id><sink_block_id>my_lte_layer_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_precoder_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_rate_match_conv_0</source_block_id><sink_block_id>my_lte_scrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_scrambler_0</source_block_id><sink_block_id>my_lte_modulation_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>my_lte_crc_attachment_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
