<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0</value></param>
<param><key>packet_len</key><value>24</value></param>
<param><key>usleep_val</key><value>20000</value></param>
</block>
<block>
<key>pdsch</key>
<param><key>id</key><value>pdsch_0</value></param>
<param><key>TBS</key><value>2112-24</value></param>
<param><key>tx_mode</key><value>1</value></param>
<param><key>M_dl_harq</key><value>6</value></param>
<param><key>rv_idx</key><value>0</value></param>
<param><key>N_soft</key><value>3654144</value></param>
<param><key>N_e_bits</key><value>6300</value></param>
<param><key>RNTI</key><value>1</value></param>
<param><key>N_code_block</key><value>1</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0_0</value></param>
<param><key>packet_len</key><value>2112-24</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
</block>
<block>
<key>pbch</key>
<param><key>id</key><value>pbch_0</value></param>
<param><key>normal_cp</key><value>1</value></param>
<param><key>cell_id</key><value>302</value></param>
<param><key>RNTI</key><value>1</value></param>
<param><key>N_ant</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>"bch_tst"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
</block>
<connection><source_block_id>my_lte_lte_random_bit_gen_0</source_block_id><sink_block_id>pbch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0_0</source_block_id><sink_block_id>pdsch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdsch_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
