<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pdsch</value></param>
<param><key>category</key><value>/MY_LTE</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M_dl_harq</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_code_block</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_e_bits</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_soft</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RNTI</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>TBS</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>my_lte_code_block_concatenation</key>
<param><key>id</key><value>my_lte_code_block_concatenation_0</value></param>
<param><key>N_e_bit_max</key><value>17700</value></param>
<param><key>N_code_block</key><value>N_code_block</value></param>
<param><key>set_align</key><value>60000</value></param>
</block>
<block>
<key>my_lte_code_block_segmentation</key>
<param><key>id</key><value>my_lte_code_block_segmentation_0</value></param>
</block>
<block>
<key>my_lte_crc_attachment</key>
<param><key>id</key><value>my_lte_crc_attachment_0</value></param>
<param><key>CRC_type</key><value>0x01864CFB</value></param>
<param><key>ch_name</key><value>"DSCH"</value></param>
<param><key>ninput_needed</key><value>20000</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>rnti</key><value>1</value></param>
</block>
<block>
<key>my_lte_layer_mapper</key>
<param><key>id</key><value>my_lte_layer_mapper_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>60000</value></param>
</block>
<block>
<key>my_lte_modulation_mapper</key>
<param><key>id</key><value>my_lte_modulation_mapper_0</value></param>
<param><key>mod_type</key><value>"QPSK"</value></param>
<param><key>set_align</key><value>60000</value></param>
</block>
<block>
<key>my_lte_precoder</key>
<param><key>id</key><value>my_lte_precoder_0</value></param>
<param><key>normal_cp</key><value>True</value></param>
<param><key>is_phich</key><value>False</value></param>
<param><key>n_phich_group</key><value>1</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>60000</value></param>
</block>
<block>
<key>my_lte_rate_match</key>
<param><key>id</key><value>my_lte_rate_match_0</value></param>
<param><key>chan_name</key><value>"PDSCH"</value></param>
<param><key>M_dl_harq</key><value>M_dl_harq</value></param>
<param><key>N_code_block</key><value>N_code_block</value></param>
<param><key>N_e_bits</key><value>N_e_bits</value></param>
<param><key>N_soft</key><value>N_soft</value></param>
<param><key>rv_idx</key><value>rv_idx</value></param>
<param><key>tx_mode</key><value>tx_mode</value></param>
</block>
<block>
<key>my_lte_rate_match</key>
<param><key>id</key><value>my_lte_rate_match_0_0</value></param>
<param><key>chan_name</key><value>"PDSCH"</value></param>
<param><key>M_dl_harq</key><value>M_dl_harq</value></param>
<param><key>N_code_block</key><value>N_code_block</value></param>
<param><key>N_e_bits</key><value>N_e_bits</value></param>
<param><key>N_soft</key><value>N_soft</value></param>
<param><key>rv_idx</key><value>rv_idx</value></param>
<param><key>tx_mode</key><value>tx_mode</value></param>
</block>
<block>
<key>my_lte_rate_match</key>
<param><key>id</key><value>my_lte_rate_match_0_1</value></param>
<param><key>chan_name</key><value>"PDSCH"</value></param>
<param><key>M_dl_harq</key><value>M_dl_harq</value></param>
<param><key>N_code_block</key><value>N_code_block</value></param>
<param><key>N_e_bits</key><value>N_e_bits</value></param>
<param><key>N_soft</key><value>N_soft</value></param>
<param><key>rv_idx</key><value>rv_idx</value></param>
<param><key>tx_mode</key><value>tx_mode</value></param>
</block>
<block>
<key>my_lte_scrambler</key>
<param><key>id</key><value>my_lte_scrambler_0</value></param>
<param><key>name</key><value>"PDSCH"</value></param>
<param><key>rnti</key><value>RNTI</value></param>
<param><key>set_align</key><value>60000</value></param>
<param><key>N_id_cell</key><value>123</value></param>
</block>
<block>
<key>my_lte_turbo_encoder</key>
<param><key>id</key><value>my_lte_turbo_encoder_0</value></param>
</block>
<block>
<key>my_lte_turbo_encoder</key>
<param><key>id</key><value>my_lte_turbo_encoder_0_0</value></param>
</block>
<block>
<key>my_lte_turbo_encoder</key>
<param><key>id</key><value>my_lte_turbo_encoder_0_1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>PDSCH</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>Source</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rv_idx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_mode</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>my_lte_code_block_concatenation_0</source_block_id><sink_block_id>my_lte_scrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_code_block_segmentation_0</source_block_id><sink_block_id>my_lte_turbo_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_crc_attachment_0</source_block_id><sink_block_id>my_lte_code_block_segmentation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_layer_mapper_0</source_block_id><sink_block_id>my_lte_precoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_modulation_mapper_0</source_block_id><sink_block_id>my_lte_layer_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_precoder_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_rate_match_0</source_block_id><sink_block_id>my_lte_code_block_concatenation_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>my_lte_rate_match_0_0</source_block_id><sink_block_id>my_lte_code_block_concatenation_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>my_lte_rate_match_0_1</source_block_id><sink_block_id>my_lte_code_block_concatenation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_scrambler_0</source_block_id><sink_block_id>my_lte_modulation_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_turbo_encoder_0</source_block_id><sink_block_id>my_lte_rate_match_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_turbo_encoder_0_0</source_block_id><sink_block_id>my_lte_rate_match_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_turbo_encoder_0_1</source_block_id><sink_block_id>my_lte_rate_match_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>my_lte_crc_attachment_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
