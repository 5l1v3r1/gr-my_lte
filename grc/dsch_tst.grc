<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>my_lte_turbo_encoder</key>
<param><key>id</key><value>my_lte_turbo_encoder_0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>my_lte_modulation_mapper</key>
<param><key>id</key><value>my_lte_modulation_mapper_0</value></param>
<param><key>mod_type</key><value>"QPSK"</value></param>
<param><key>set_align</key><value>60000</value></param>
</block>
<block>
<key>my_lte_code_block_segmentation</key>
<param><key>id</key><value>my_lte_code_block_segmentation_0</value></param>
</block>
<block>
<key>my_lte_layer_mapper</key>
<param><key>id</key><value>my_lte_layer_mapper_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>60000</value></param>
</block>
<block>
<key>my_lte_rate_match</key>
<param><key>id</key><value>my_lte_rate_match_0</value></param>
<param><key>N_e_bits</key><value>6300</value></param>
<param><key>N_code_block</key><value>1</value></param>
<param><key>tx_mode</key><value>1</value></param>
<param><key>N_soft</key><value>3654144</value></param>
<param><key>M_dl_harq</key><value>6</value></param>
<param><key>rv_idx</key><value>0</value></param>
<param><key>chan_name</key><value>"PDSCH"</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>my_lte_crc_attachment</key>
<param><key>id</key><value>my_lte_crc_attachment_0</value></param>
<param><key>CRC_type</key><value>0x01864CFB</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>ch_name</key><value>"DSCH"</value></param>
<param><key>ninput_needed</key><value>20000</value></param>
<param><key>rnti</key><value>1</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
</block>
<block>
<key>my_lte_precoder</key>
<param><key>id</key><value>my_lte_precoder_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>set_align</key><value>60000</value></param>
<param><key>is_phich</key><value>False</value></param>
<param><key>n_phich_group</key><value>1</value></param>
<param><key>normal_cp</key><value>True</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0</value></param>
<param><key>packet_len</key><value>2112</value></param>
<param><key>usleep_val</key><value>200</value></param>
</block>
<block>
<key>my_lte_code_block_concatenation</key>
<param><key>id</key><value>my_lte_code_block_concatenation_0</value></param>
<param><key>N_code_block</key><value>1</value></param>
<param><key>N_e_bit_max</key><value>17700</value></param>
<param><key>set_align</key><value>60000</value></param>
</block>
<block>
<key>my_lte_scrambler</key>
<param><key>id</key><value>my_lte_scrambler_0</value></param>
<param><key>N_id_cell</key><value>302</value></param>
<param><key>name</key><value>"PDSCH"</value></param>
<param><key>rnti</key><value>1</value></param>
<param><key>set_align</key><value>6300</value></param>
</block>
<connection><source_block_id>my_lte_crc_attachment_0</source_block_id><sink_block_id>my_lte_code_block_segmentation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_code_block_segmentation_0</source_block_id><sink_block_id>my_lte_turbo_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_turbo_encoder_0</source_block_id><sink_block_id>my_lte_rate_match_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_scrambler_0</source_block_id><sink_block_id>my_lte_modulation_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_code_block_concatenation_0</source_block_id><sink_block_id>my_lte_scrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_rate_match_0</source_block_id><sink_block_id>my_lte_code_block_concatenation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_layer_mapper_0</source_block_id><sink_block_id>my_lte_precoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_modulation_mapper_0</source_block_id><sink_block_id>my_lte_layer_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0</source_block_id><sink_block_id>my_lte_crc_attachment_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_precoder_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
