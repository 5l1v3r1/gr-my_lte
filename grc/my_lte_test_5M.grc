<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M_dl_harq</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_ant</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_code_block</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_e_bits</value></param>
<param><key>value</key><value>6300</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_id_1</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_id_2</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_soft</value></param>
<param><key>value</key><value>3654144</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TBS</value></param>
<param><key>value</key><value>2112</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cell_id</value></param>
<param><key>value</key><value>N_id_1 * 3 + N_id_2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>normal_cp</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rnti</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rv_idx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30720000/40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>MCS</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_CCE</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>13</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_dl_prb</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>PCFICH</key>
<param><key>id</key><value>PCFICH_0</value></param>
<param><key>RNTI</key><value>rnti</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
</block>
<block>
<key>PDCCH</key>
<param><key>id</key><value>PDCCH_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>N_CCE</key><value>N_CCE</value></param>
<param><key>N_ant</key><value>N_ant</value></param>
<param><key>RNTI</key><value>rnti</value></param>
<param><key>aggregation1</key><value>aggregation1</value></param>
<param><key>aggregation2</key><value>aggregation2</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>num_pdcch</key><value>n_pdcch</value></param>
</block>
<block>
<key>PDSCH_5M</key>
<param><key>id</key><value>PDSCH_5M_0</value></param>
<param><key>M_dl_harq</key><value>M_dl_harq</value></param>
<param><key>N_code_block</key><value>N_code_block</value></param>
<param><key>N_e_bits</key><value>N_e_bits</value></param>
<param><key>N_soft</key><value>N_soft</value></param>
<param><key>RNTI</key><value>rnti</value></param>
<param><key>TBS</key><value>TBS</value></param>
<param><key>rv_idx</key><value>rv_idx</value></param>
<param><key>tx_mode</key><value>tx_mode</value></param>
</block>
<block>
<key>PHICH_3_group</key>
<param><key>id</key><value>PHICH_3_group_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>RNTI</key><value>rnti</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RB_start_UE_1</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RB_start_UE_2</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>70</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>aggregation1</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>288</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>aggregation2</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>288*2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>allocation_len_UE_1</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>allocation_len_UE_2</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/mostafa/Desktop/LTE_Signal/matlabfiles/ffo/grc_data_5M.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"length"</value></param>
<param><key>packet_len</key><value>12*3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>"length"</value></param>
<param><key>packet_len</key><value>N_CCE*9*8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>len_tag_key</key><value>"length"</value></param>
<param><key>packet_len</key><value>16</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfi_val</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>my_lte_cfi_gen</key>
<param><key>id</key><value>my_lte_cfi_gen_0</value></param>
<param><key>cfi_val</key><value>cfi_val</value></param>
<param><key>N_dl_prb</key><value>N_dl_prb</value></param>
</block>
<block>
<key>my_lte_cp_adder</key>
<param><key>id</key><value>my_lte_cp_adder_0</value></param>
<param><key>N_dl_prb</key><value>N_dl_prb</value></param>
<param><key>normal_cp</key><value>True</value></param>
</block>
<block>
<key>my_lte_dci_gen</key>
<param><key>id</key><value>my_lte_dci_gen_0</value></param>
<param><key>alloc_len</key><value>allocation_len_UE_1</value></param>
<param><key>carrier_ind</key><value>False</value></param>
<param><key>dci_t</key><value>"1A"</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>N_dl_harq</key><value>M_dl_harq</value></param>
<param><key>N_dl_prb</key><value>N_dl_prb</value></param>
<param><key>ndi</key><value>False</value></param>
<param><key>N_ant</key><value>N_ant</value></param>
<param><key>N_layers</key><value>N_ant</value></param>
<param><key>RB_start</key><value>RB_start_UE_1</value></param>
<param><key>rnti</key><value>rnti</value></param>
<param><key>rv_idx</key><value>rv_idx</value></param>
<param><key>tx_mode</key><value>tx_mode</value></param>
<param><key>mcs</key><value>MCS</value></param>
</block>
<block>
<key>my_lte_dci_gen</key>
<param><key>id</key><value>my_lte_dci_gen_0_0</value></param>
<param><key>alloc_len</key><value>allocation_len_UE_2</value></param>
<param><key>carrier_ind</key><value>False</value></param>
<param><key>dci_t</key><value>"1A"</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>N_dl_harq</key><value>M_dl_harq</value></param>
<param><key>N_dl_prb</key><value>N_dl_prb</value></param>
<param><key>ndi</key><value>False</value></param>
<param><key>N_ant</key><value>N_ant</value></param>
<param><key>N_layers</key><value>N_ant</value></param>
<param><key>RB_start</key><value>RB_start_UE_2</value></param>
<param><key>rnti</key><value>1+10</value></param>
<param><key>rv_idx</key><value>rv_idx</value></param>
<param><key>tx_mode</key><value>tx_mode</value></param>
<param><key>mcs</key><value>MCS</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0</value></param>
<param><key>packet_len</key><value>24</value></param>
<param><key>usleep_val</key><value>20000</value></param>
</block>
<block>
<key>my_lte_lte_random_bit_gen</key>
<param><key>id</key><value>my_lte_lte_random_bit_gen_0_0</value></param>
<param><key>packet_len</key><value>2112-24</value></param>
<param><key>usleep_val</key><value>2000</value></param>
</block>
<block>
<key>my_lte_resource_mapper</key>
<param><key>id</key><value>my_lte_resource_mapper_0</value></param>
<param><key>N_dl_prb</key><value>N_dl_prb</value></param>
<param><key>N_id_1</key><value>N_id_1</value></param>
<param><key>N_id_2</key><value>N_id_2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n_pdcch</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pbch</key>
<param><key>id</key><value>pbch_0</value></param>
<param><key>N_ant</key><value>N_ant</value></param>
<param><key>RNTI</key><value>rnti</value></param>
<param><key>cell_id</key><value>cell_id</value></param>
<param><key>normal_cp</key><value>normal_cp</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>PCFICH_0</source_block_id><sink_block_id>my_lte_resource_mapper_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>PDCCH_0</source_block_id><sink_block_id>my_lte_resource_mapper_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>PDSCH_5M_0</source_block_id><sink_block_id>my_lte_resource_mapper_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>PHICH_3_group_0</source_block_id><sink_block_id>blocks_throttle_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>my_lte_resource_mapper_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>my_lte_resource_mapper_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_1</source_block_id><sink_block_id>my_lte_resource_mapper_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pbch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>PDSCH_5M_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>PDCCH_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_0</source_block_id><sink_block_id>PCFICH_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_1</source_block_id><sink_block_id>my_lte_resource_mapper_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>my_lte_cfi_gen_0</source_block_id><sink_block_id>blocks_throttle_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_cp_adder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_dci_gen_0</source_block_id><sink_block_id>blocks_throttle_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_dci_gen_0_0</source_block_id><sink_block_id>PDCCH_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_lte_random_bit_gen_0_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>my_lte_resource_mapper_0</source_block_id><sink_block_id>my_lte_cp_adder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_0</source_block_id><sink_block_id>my_lte_resource_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
